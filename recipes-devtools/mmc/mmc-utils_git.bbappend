SRCREV = "b7e4d5a6ae9942d26a11de9b05ae7d52c0802802"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-PPEU-command.patch"

